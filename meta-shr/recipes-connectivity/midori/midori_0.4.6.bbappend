RDEPENDS_${PN} += "gtk-theme-clearlooks-gtkrc"

PRINC := "${@int(PRINC) + 1}"
