RDEPENDS_avahi-daemon = ""
PRINC = "1"
