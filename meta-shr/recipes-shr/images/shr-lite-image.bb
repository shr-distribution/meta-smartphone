require shr-image.inc
