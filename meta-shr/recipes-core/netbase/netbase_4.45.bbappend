FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}"
PRINC = "2"
