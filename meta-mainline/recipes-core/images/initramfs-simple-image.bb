SUMMARY = "Initramfs image to boot from internal flash with initramfs"
DESCRIPTION = "Provides a minimal environment to bootstrap and run LuneOS"

require initramfs-simple-image.inc
