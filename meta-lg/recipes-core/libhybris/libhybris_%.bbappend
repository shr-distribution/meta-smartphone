# we have android-headers-mako
COMPATIBLE_MACHINE_mako = "(^mako$)"
