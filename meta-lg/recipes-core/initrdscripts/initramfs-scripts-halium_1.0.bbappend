FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"


COMPATIBLE_MACHINE:mako-halium = "mako-halium"
