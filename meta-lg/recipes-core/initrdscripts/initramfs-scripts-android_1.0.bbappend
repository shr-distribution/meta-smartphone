FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:hammerhead-halium = "hammerhead-halium"
COMPATIBLE_MACHINE:hammerhead = "hammerhead"
COMPATIBLE_MACHINE:mako = "mako"
