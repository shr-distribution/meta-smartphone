FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_mako = "mako"
COMPATIBLE_MACHINE_hammerhead = "hammerhead"
