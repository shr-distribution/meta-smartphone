COMPATIBLE_MACHINE_palmpre = "palmpre"
# We don't have x-load support for palmpre yet so we choose beagleboard here
XLOAD_MACHINE_palmpre = "omap3530beagle_config"
