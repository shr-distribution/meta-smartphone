COMPATIBLE_MACHINE_palmpre = "palmpre"

# We don't have palmpre support for u-boot so we use beagleboards config for now
UBOOT_MACHINE_palmpre = "omap3_beagle_config"
