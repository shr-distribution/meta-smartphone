require cornucopia.inc

DESCRIPTION = "freesmartphone.org support library"
DEPENDS += "libnl"
SRCREV = "${FSO_CORNUCOPIA_SRCREV}"
PV = "0.11.0+gitr${SRCPV}"
PE = "1"
PR = "${INC_PR}.0"
