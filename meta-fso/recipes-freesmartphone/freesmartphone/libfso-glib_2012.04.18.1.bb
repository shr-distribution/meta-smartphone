require ${BPN}.inc

SRC_URI[md5sum] = "7acbf5b74cebc02c31644b1b167fa4da"
SRC_URI[sha256sum] = "b92f56107945eb5d4328ec49249b116c39a26fa4aaa585bc7e79622a64a1f6f7"
