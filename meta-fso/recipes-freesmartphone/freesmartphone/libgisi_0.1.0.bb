require ${BPN}.inc

PR = "r2"

SRC_URI += "file://0001-do-not-include-gtypes.h-new-glib-2.32.1-doesn-t-like.patch"
SRC_URI[md5sum] = "c2366a650628d9166f52866681f9977d"
SRC_URI[sha256sum] = "66953ac8b2453bcd218df1fd051b2c759df4bcc71f2ec2c69fcba6c7874b197c"
