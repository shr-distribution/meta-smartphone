require ${BPN}.inc

PR = "r1"

SRC_URI[md5sum] = "89f1be0e9869cdd7bc9345629cfbb5ce"
SRC_URI[sha256sum] = "24bb6c0ca77324bff20b47f1be8cbfcb214e9059a530240d34924839e873f90a"
