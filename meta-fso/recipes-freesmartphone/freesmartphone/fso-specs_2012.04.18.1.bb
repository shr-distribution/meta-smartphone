require ${BPN}.inc

SRC_URI[md5sum] = "3289f6916f218ff6544ee1506a3990b0"
SRC_URI[sha256sum] = "b74ccdb96c559abdd91edb7e2f9955f5a4c67b8a7dea639f6ac8b19bb0888358"
