require ${BPN}.inc

SRC_URI[md5sum] = "b82a034818ac2e2c94cd5e91e54544ee"
SRC_URI[sha256sum] = "27101cd85580838178c9f8b177393d9ab245cd746e17a215f7978c3811e27c5c"
