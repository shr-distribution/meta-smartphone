require ${BPN}.inc

SRC_URI[md5sum] = "16951fbbda1b35b46509c19eb0c6109b"
SRC_URI[sha256sum] = "5be8ad929626d0a3751607f06af8529d2796e7609f201fe74790f37437577450"
