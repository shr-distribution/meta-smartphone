require ${BPN}.inc

PR = "r1"

SRC_URI[md5sum] = "c69db48f9203de9ac6c932cc469b61cd"
SRC_URI[sha256sum] = "a65298ebf0edba6469280e56f93b0e6df088b9a4f76d9f4520dac3521d183612"
