require ${BPN}.inc

SRC_URI[md5sum] = "60048bdb3b166c7ca0ffdbc3cb6559d0"
SRC_URI[sha256sum] = "dc70d2880d01caa9209fd1164fcbb33c1490856d51926cbd03df1a3a5f1eed5a"
