require ${BPN}.inc

SRC_URI[md5sum] = "894710ec7f962b45a5fbe0d3d092ce3b"
SRC_URI[sha256sum] = "4c92d3d49bbb28b32bf6d6aeb0ef0cdcfe1d84b08cc560e1abe295d1321db508"
