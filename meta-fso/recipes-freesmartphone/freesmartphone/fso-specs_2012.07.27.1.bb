require ${BPN}.inc

SRC_URI[md5sum] = "18b78f4cb6badd6f214448b6c5e536bc"
SRC_URI[sha256sum] = "a9a8f6571362831d91aa229f9694de6027c9f8c6f6a81e4a03ffa7a4f5642110"
