require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "499717495250a4ac45fcaff65db5beaf"
SRC_URI[sha256sum] = "cda0b267aa570b18d6791ce0ce496f31568c4ba827299676b6a969c6107a42e5"
