require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1f97b7f59a677ca44aa2fe3606f214eb"
SRC_URI[sha256sum] = "0acbee1075f02ee64cb8153844a71d44347cf9f42011ac85677fbde3b62013b0"
