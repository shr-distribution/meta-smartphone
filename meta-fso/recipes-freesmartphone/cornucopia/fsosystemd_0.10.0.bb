require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "5884a5159d6589b8abd385e88394b5e9"
SRC_URI[sha256sum] = "4af20da96f3c162ac3a93ef4b7d61dbd5579827fa018e7c13e89a39960aca70c"
