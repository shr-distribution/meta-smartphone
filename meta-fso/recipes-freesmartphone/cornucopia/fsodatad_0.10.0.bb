require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c75d07f39482c27f7aa065948860ec46"
SRC_URI[sha256sum] = "1cc69de2f9ea03f66fe41361dd442bd3eb1272d1458a04fead7d116652e02b58"
