require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "efb44cb4c5cf2c2f479fb5c83650bd8e"
SRC_URI[sha256sum] = "334914d4d2f7bc52ee3352b49e4c51de6fef33cd37a2907e1c41fd5d5557ee03"
