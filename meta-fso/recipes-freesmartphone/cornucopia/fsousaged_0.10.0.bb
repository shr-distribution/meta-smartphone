require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "90a3b494e687f49779024e15f08797b0"
SRC_URI[sha256sum] = "b3cdf2d3e0f500c17032f433c84464272111adecdc67c3f2ac94d67d7a9ce869"
