require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "fe2b80335b917fbbfba972e5c3259381"
SRC_URI[sha256sum] = "f7985035c9abb9eb4ce23f62df8423c309fba960ee06215e4638aab9322f77df"
