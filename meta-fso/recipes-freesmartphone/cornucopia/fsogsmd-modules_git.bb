require ${BPN}.inc

DEFAULT_PREFERENCE = "-1"
PV = "0.10.99"
