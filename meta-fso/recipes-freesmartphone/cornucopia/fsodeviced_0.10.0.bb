require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "b71182cf463d302af0323b70312b18a4"
SRC_URI[sha256sum] = "858a3aed8b486daf54d586fd47c32d9c6cf95a2e230c4b8952fc5f72938c95c7"
