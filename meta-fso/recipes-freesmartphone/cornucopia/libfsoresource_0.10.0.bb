require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0f536b1f172dcc258d0578b4fb1e7737"
SRC_URI[sha256sum] = "223f56020b7efb2fb6683a6be606762717941a8253b680ae4c91eff412e4e367"
