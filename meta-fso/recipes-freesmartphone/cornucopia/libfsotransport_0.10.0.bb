require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8e8ffb777591f6d9c1812819d55d8a8e"
SRC_URI[sha256sum] = "0d43e721ef9887b1fa40f93025babafbc0e840fce94cc4ef038ba40e2da2bd64"
