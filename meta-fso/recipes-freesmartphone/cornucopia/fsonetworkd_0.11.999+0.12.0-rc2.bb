require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "6f7ba87c2b2b009e4db0747e2f1cd729"
SRC_URI[sha256sum] = "b0aa5e2a65d3fd0e6e35d514aa731ef9eba4c2dce67d5d3bba04e8187a57fb2c"
