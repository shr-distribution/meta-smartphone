require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f0cb4d8200af8b0045a42a2f29730905"
SRC_URI[sha256sum] = "fffa86f7d75b7333543fa7a0e2c1911e57ec64d713c61f42e4ecfc18ddf6c723"
