require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "dc8655ac57c3376147c8be0e3e0c405b"
SRC_URI[sha256sum] = "9da9842985d41c26674677d8cc3d6d907bf3c67dc04bc107f163b24019e2bbf7"
