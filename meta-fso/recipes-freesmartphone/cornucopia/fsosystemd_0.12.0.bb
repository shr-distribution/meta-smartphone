require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "360a8d30fd3c4679c8ce78d33ff2b0e5"
SRC_URI[sha256sum] = "17b18e2518053ebf1f0c036fc95f462f42c8357585be9bd9821facda39aeca95"
