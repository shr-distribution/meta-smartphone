require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "cde4f99cee887776cd5a4a27c60b3cd8"
SRC_URI[sha256sum] = "3d6e29f3c57257e629b21ff0de7a936f2d90250232db126337e9c3998876c94c"
