require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ba63c3f389692c2b3fc199b8c905b119"
SRC_URI[sha256sum] = "35c3081436b01b8fb568c0414d93e7dfef55d4645a9f0cdf53674cfb06d7b116"
