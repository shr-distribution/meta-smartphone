require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "264d50b3ae98f35028481edd2b5aa1c8"
SRC_URI[sha256sum] = "9c5ee5247f7fae0c0d0e73faf2aa977ee5f974bc9deb4d0bd991f93b74471a37"
