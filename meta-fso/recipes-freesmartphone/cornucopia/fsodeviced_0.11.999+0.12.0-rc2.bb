require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "627f02a5311c914b3daa6e7274556d40"
SRC_URI[sha256sum] = "80123c0bbbbaed62eaeb353edcd717dc25b7d507fa916ebaad6cc970ef81eae6"
