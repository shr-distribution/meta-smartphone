require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "35cfc9aa57faf6678b2e3dbbb9e79a04"
SRC_URI[sha256sum] = "bc9efe02c989e9755d7cb918ccb4a12d27cad74acc46ed0013f0751557e464f7"
