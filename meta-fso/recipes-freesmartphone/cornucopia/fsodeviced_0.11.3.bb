require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "58e5ae0fd22cd5dc3e645e04b8b9431b"
SRC_URI[sha256sum] = "eeb5e056b30eeb35b57219cac32995144dde4ccfb04c2a99baea73f606156876"
