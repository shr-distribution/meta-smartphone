require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0184290ac20405b0a1f3356ae7c932dd"
SRC_URI[sha256sum] = "b0c1203f686a76c0f5ef83132acd908e54e98dcb4cb2f533a3f3346eec58b064"
