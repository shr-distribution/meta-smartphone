require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1d57f6a14af72715f6ee67e87716270f"
SRC_URI[sha256sum] = "ddd9e5adfc5c0b8ae6e06baf83f1ee18d5125f3e3f7d816d18190f25db1b8538"
