require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "278e1361431fcc9cd94eeec80d6b565b"
SRC_URI[sha256sum] = "0015d74b081d7231e660b6da7a323a857ba508685a3c3c6e9e07b63db048706a"
