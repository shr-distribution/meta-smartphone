require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f4323b17d856264638dc44a8db6594c2"
SRC_URI[sha256sum] = "33e206e10e8c88e5d07f9587f8bcf92b918ba413cd8744ede0c9daadc4327b32"
