require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ac779f790acf169ed8125df5e21f684a"
SRC_URI[sha256sum] = "5264828db06b11f2485400f3a34d90f885e549b3cca508f64a5b6f65856cc29f"
