require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1f5b2ec7e69a83da3c53178f921274d9"
SRC_URI[sha256sum] = "90fbd4f5293599ab23f724bb72a8815a45a4fa9aa0463284ab2dae65e94b9d53"
