require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c19715081816b562c5e10643b44c6caa"
SRC_URI[sha256sum] = "7d7f72ab2c0ee0afb6a3bcb5ad60c0bc29f4dc52c9e5c117838d7f5835a56242"
