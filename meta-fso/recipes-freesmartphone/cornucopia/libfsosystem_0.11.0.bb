require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ba551bdba4e75d2282fdcc5d0afcfb94"
SRC_URI[sha256sum] = "a77b0dc14e9e9203cb1b8e39bba328da79fb0c98d0ca7021abb8609450835f67"
