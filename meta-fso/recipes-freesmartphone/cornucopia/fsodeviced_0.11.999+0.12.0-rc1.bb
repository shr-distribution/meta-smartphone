require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "2ed55d2e6184d977d2d91571c7ecba20"
SRC_URI[sha256sum] = "c27d50511cbe41900d76fed0ac239cc8b2cb73b0f42ea884b2697f372fd75ce2"
