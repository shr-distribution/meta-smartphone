require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "74aaf2ec07aaa7edeefcfcc1c1167f0d"
SRC_URI[sha256sum] = "eb5bfd3baeb185140c59fe69a554670368d72746c3f65d59ed7fb45295c849d4"
