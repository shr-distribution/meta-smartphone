require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "7af57a160cebcf9f49a3a050d14f925f"
SRC_URI[sha256sum] = "a4d9406162dc4300cb02a150ae275ef2bde51cd02ca8c4aef960ceb9d267baf6"
