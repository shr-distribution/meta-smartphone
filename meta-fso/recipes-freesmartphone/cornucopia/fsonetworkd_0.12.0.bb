require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "a78e18096c16e1aa058350b55dbf735f"
SRC_URI[sha256sum] = "d18367cd4915411ac931b13d3b1427ef1b1c385db55632142d928648590d3b93"
