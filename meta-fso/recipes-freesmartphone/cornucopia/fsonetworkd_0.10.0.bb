require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "367fd068e1a6f2792488e579192ff12f"
SRC_URI[sha256sum] = "af4953924d8a07dd21dd3c849b4c2529b5afed7cb785d8a60f45d4fc95bcb9f9"
