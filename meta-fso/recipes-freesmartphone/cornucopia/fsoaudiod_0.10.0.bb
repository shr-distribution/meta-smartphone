require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[sha256sum] = "f4338fe985d8b3252cba895cfb18e6022bd1851c7d3451b82902083ae5bfa088"
SRC_URI[md5sum] = "e27bd7d36dfe3eeaf319fce03d308644"
