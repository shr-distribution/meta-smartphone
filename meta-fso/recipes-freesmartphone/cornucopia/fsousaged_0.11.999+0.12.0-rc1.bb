require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "4f96cbb8ab7b0129731ae43348d81c9b"
SRC_URI[sha256sum] = "f1ad8340ca7b85008000aea03bee4ba0e4e6c6c28c8ee552c6b1c701dbaf26a4"
