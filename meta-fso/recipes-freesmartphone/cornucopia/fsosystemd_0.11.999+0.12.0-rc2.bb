require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "463a91dc1270cd9f22011eeaaac798bd"
SRC_URI[sha256sum] = "1dec458b46b1694fae9f67e7e27b53fcf4abb1026813815df6d0df54674e8836"
