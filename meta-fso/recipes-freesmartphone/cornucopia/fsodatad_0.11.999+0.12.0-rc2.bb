require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "7c1096f6c2980eb9f14f13b54327b3e5"
SRC_URI[sha256sum] = "fc6fc6677761547a9aaa5a79470f4f3e6e1f7207a1658f02a3c8c7c2a4a5c8f5"
