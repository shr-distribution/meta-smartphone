require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "7244267ba1efd10a47f98f473111e791"
SRC_URI[sha256sum] = "0d0de05e38711649a5ff02aaf1d06bfdf2f7c8e06ce95f52e9db6e6d8ac9761f"
