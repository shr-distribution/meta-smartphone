require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d4269c951f70d1789c38097f58456ae1"
SRC_URI[sha256sum] = "5c95775e0520b46fe2523cc6fed2bc3f24d563fab9ace7a68a7a14671e728aac"
