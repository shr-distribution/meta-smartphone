require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "a24c34366c6f7888a436e1626baffa59"
SRC_URI[sha256sum] = "797f23f32684fc2f0b5667b52a00ecf97bb51c89c600bc45fa613b686f7858b6"
