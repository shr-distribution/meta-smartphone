require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "6fef51bc8125e462ea4223475e13cc90"
SRC_URI[sha256sum] = "dd379cc6a802975f470c2921fb112800941bbb410109dd2a5f9f371e1fd63123"
