require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "10c575b77c4e2b9d5c359cdb0cfc63f9"
SRC_URI[sha256sum] = "dc8ef11810026f25e56c6a4e3ac6d48709522879646fb101b0a0b27708003dfe"
