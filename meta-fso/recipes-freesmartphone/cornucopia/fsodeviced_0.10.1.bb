require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "cea6d010226108bfcd04e73b118ae4f9"
SRC_URI[sha256sum] = "b38b97818d3677b42b3321570e2f454955d2c6c14b6b59dcd71180caed67c60f"
