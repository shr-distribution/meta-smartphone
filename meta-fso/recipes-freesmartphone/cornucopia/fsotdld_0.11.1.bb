require ${BPN}.inc

PR = "${INC_PR}.1"

SRC_URI += "file://0001-fsotdld-provider_location_cellidwifi-link-against-in.patch"

SRC_URI[md5sum] = "e0e09f840560fd3db0ea7ad16d6ed6c6"
SRC_URI[sha256sum] = "75efee7cfabaf4c6a6f8734294d631ce67e06cdeff3ad693044db92dad00db26"
