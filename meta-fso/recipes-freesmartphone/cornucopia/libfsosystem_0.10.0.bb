require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "3972d14a1e3c29b29d09c054c84a224f"
SRC_URI[sha256sum] = "90977f6da7da437a4668a522008168fc418ad39f8a1355d6d3ed79018b2a64d7"
