require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "053750f5bc41dcbc5f2b2c2c8c86dde1"
SRC_URI[sha256sum] = "c8cd4d8189fd826bb166119bb3e4ed0c759f4bbd45e913b534f571bfb08cf338"
