require ${BPN}.inc
require msmcomm-from-git.inc

SRCREV = "${MSMCOMM_SRCREV}"

PV = "0.1.0+gitr${SRCPV}"
PR = "${INC_PR}.0"
