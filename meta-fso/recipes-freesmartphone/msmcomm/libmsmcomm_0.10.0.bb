require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "bc67e3d2fc33b844de93193fbd76bee4"
SRC_URI[sha256sum] = "e791e1d98a9e537b6715fde40860e407a15f3982e5c63598119f27f37f033865"
