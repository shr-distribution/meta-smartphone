require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d1f22fd399bea6cfb3cc0241a203d994"
SRC_URI[sha256sum] = "a464b8aa59a27bbf5cacbe6dae8e94c19e18e5852c3e6ed6c7d0c9d1fe71d87d"
