require ${BPN}.inc

SRC_URI[md5sum] = "667781a80cc21ef388fa19aa5ad25941"
SRC_URI[sha256sum] = "a7ecc11b596e022ac09748eb883437bdcfa09005a441a3f933ffcbcdad47f05f"
