# because of defaults overriden in machine config
PACKAGE_ARCH_om-gta01 = "${MACHINE_ARCH}"
PACKAGE_ARCH_om-gta02 = "${MACHINE_ARCH}"
PACKAGE_ARCH_om-gta04 = "${MACHINE_ARCH}"
