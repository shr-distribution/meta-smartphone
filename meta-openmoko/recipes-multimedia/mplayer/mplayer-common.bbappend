FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PACKAGE_ARCH_om-gta02 = "${MACHINE_ARCH}"
