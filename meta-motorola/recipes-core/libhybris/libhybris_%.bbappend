# we have android-headers-athene
COMPATIBLE_MACHINE_athene = "(^athene$)"
