EXTRA_OECONF_append_shr = "\
  --enable-fso \
"
