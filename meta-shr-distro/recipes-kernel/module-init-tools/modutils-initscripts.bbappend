PRINC := "${@int(PRINC) + 1}"
INITSCRIPT_PARAMS = "start 39 S ."

