RDEPENDS_${PN} += "gtk-theme-clearlooks-gtkrc"
