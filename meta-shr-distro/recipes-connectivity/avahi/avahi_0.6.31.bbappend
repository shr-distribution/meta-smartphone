RDEPENDS_avahi-daemon = ""
PRINC := "${@int(PRINC) + 1}"
