PRINC := "${@int(PRINC) + 6}"
