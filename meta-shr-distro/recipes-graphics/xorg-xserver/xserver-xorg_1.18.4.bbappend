FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://randr-support.patch"
