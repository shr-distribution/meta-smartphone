# we have android-headers-onyx
COMPATIBLE_MACHINE_onyx = "(^onyx$)"
