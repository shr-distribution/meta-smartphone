FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:sargo = "^sargo$"
COMPATIBLE_MACHINE:sunfish = "^sunfish$"
COMPATIBLE_MACHINE:bramble = "^bramble$"
