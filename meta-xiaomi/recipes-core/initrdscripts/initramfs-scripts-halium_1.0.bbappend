FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:mido = "^mido$"
COMPATIBLE_MACHINE:oxygen = "^oxygen$"
COMPATIBLE_MACHINE:rosy = "^rosy$"
COMPATIBLE_MACHINE:sagit = "^oxygen$"
COMPATIBLE_MACHINE:tissot = "^tissot$"

