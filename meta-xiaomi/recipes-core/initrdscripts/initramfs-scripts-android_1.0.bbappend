FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:rosy = "^rosy$"
COMPATIBLE_MACHINE:tissot = "^tissot$"
