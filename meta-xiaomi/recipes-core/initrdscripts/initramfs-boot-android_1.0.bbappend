FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_mido = "^mido$"
COMPATIBLE_MACHINE_tissot = "^tissot$"
COMPATIBLE_MACHINE_rosy = "^rosy$"
