SRC_URI_crespo = "git://github.com/morphis/xf86-input-mtev.git;protocol=git;branch=samsung-crespo-support"
SRCREV_crespo = "64c1940f2d9f4ce4487be7d18d866db5a426b119"
PACKAGE_ARCH_crespo = "${MACHINE_ARCH}"
