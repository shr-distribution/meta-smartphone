# we have android-headers-maguro
COMPATIBLE_MACHINE_maguro = "(^maguro$)"
