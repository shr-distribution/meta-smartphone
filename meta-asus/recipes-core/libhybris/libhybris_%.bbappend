# we have android-headers-grouper
COMPATIBLE_MACHINE_grouper = "(^grouper$)"
