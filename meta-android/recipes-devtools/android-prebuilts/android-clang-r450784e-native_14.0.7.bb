# Android (8508608, based on r450784e) clang version 14.0.7: android13-5.15 (brax3).
require android-clang.inc

ANDROID_CLANG_VERSION = "r450784e"
SRCREV = "7154d3eddcb62ff7909a6ae2bf0c03e445e65bc4"
