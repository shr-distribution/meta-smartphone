# The snapshot the android-gs-bluejay-6.1-android16 kernel manifest pins
# (pahole v1.23): the android14-6.1 GKI (bluejay, panther, tangorpro) and the
# android15-6.6 one (lagos).
require android-kernel-build-tools.inc

ANDROID_BUILD_TOOLS_NAME = "gs-6.1"
PV = "0+git"
SRCREV = "e905be252a53d20c52bd9e59df3ff8fdd46b9eab"
