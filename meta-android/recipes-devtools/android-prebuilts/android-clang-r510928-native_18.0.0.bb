# Android (11368308, +pgo, +bolt, +lto, +mlgo, based on r510928) clang version 18.0.0: android15-6.6 (lagos).
require android-clang.inc

ANDROID_CLANG_VERSION = "r510928"
SRCREV = "7154d3eddcb62ff7909a6ae2bf0c03e445e65bc4"
