# The snapshot the common-android12-5.10 kernel manifest pins (pahole v1.19):
# q25, mp01, bramble.
require android-kernel-build-tools.inc

ANDROID_BUILD_TOOLS_NAME = "android12-5.10"
PV = "0+git"
SRCREV = "ca5b087f88c0302ff66f59a6f26be663e92baf15"
