# we have android-headers-angler
COMPATIBLE_MACHINE_angler = "(^angler$)"
